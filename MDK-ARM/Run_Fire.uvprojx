# Keil uVision project Run_Fire.uvprojx, settings and files
target Run_Fire (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Run_Fire +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F746xx
  c include: ../Core/Inc;                    C:/Users/chiur/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Drivers/STM32F7xx_HAL_Driver/Inc;                    C:/Users/chiur/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;                    C:/Users/chiur/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Middlewares/Third_Party/FreeRTOS/Source/include;                    C:/Users/chiur/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;                    C:/Users/chiur/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;                    C:/Users/chiur/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Drivers/CMSIS/Device/ST/STM32F7xx/Include;                    C:/Users/chiur/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Drivers/CMSIS/Include;                    ..\BSP_746\Inc;                    ..\mainFSM\Inc;                    ..\ButtonHandler\Inc
  asm include: ..\Core\Inc;..\BSP_746\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32f7xx_it.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c
  group Drivers/STM32F7xx_HAL_Driver
    C:/Users/chiur/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Middlewares/FreeRTOS
    C:/Users/chiur/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    C:/Users/chiur/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    C:/Users/chiur/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    C:/Users/chiur/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group BSP_746
    ../BSP_746/Src/: BSP_746.c
  group mainFSM
    ../mainFSM/Src/: mainFSM.c
  group ButtonHandler
    ../ButtonHandler/Src/: ButtonHandler.c
    ../ButtonHandler/Inc/: ButtonHandler.h
software components: CMSIS:CORE 5.5.0
